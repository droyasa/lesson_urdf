Commit message: Update planar_2dof.urdf
2 DOF Planar

File: urdf/planar_3dof.urdf (robot description, URDF)
Before this commit: robot planar_3dof, 6 links, 5 joints
Links:
- removed link end
- removed link gripper
Joints:
- removed joint gripper_end
- removed joint joint_3
